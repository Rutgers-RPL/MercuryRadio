# IAR project cc120x_easy_link.ewp, settings and files
configuration TX (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.IExtraOptions: --diag_remark=Pe177
  ICC430.newCCIncludePaths: ..\..\..\source\components\targets\trxeb_msp430f5438a; ..\..\..\source\components\bsp\trxeb_msp5438a\drivers\source; ..\..\..\source\components\targets\interface; ..\..\..\source\components\common; ..\..\..\source\components\common\msp430; ..\..\..\source\components\devices\cc120x; ..\..\..\source\components\devices\lcd_dogm128_6
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration RX (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: EASY_LINK_TX
  group (top)
    ../../../source/apps/cc120x_easy_link/: cc120x_easy_link_reg_config.h cc120x_easy_link_rx.c cc120x_easy_link_tx.c
  group bsp
    ../../../source/components/bsp/trxeb_msp5438a/drivers/source/: als_trxeb.c bsp.c bsp_key.c bsp_led.c bsp_uart.c flash_trxeb.c io_pin_int.c lcd_dogm128_6.c lcd_dogm128_6_alphabet.c lcd_trxeb.c
  group hal
    ../../../source/components/devices/cc120x/: cc120x_spi.c
    ../../../source/components/targets/trxeb_msp430f5438a/: hal_spi_rf_trxeb.c
